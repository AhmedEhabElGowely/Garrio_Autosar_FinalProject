# IAR project Autosar_Final_Project_Gowely.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ButtonManager_SWC_1.c CDD_SWC_1.c LedControl_SWC_2.c main.c Rte.c Rte.h Rte_ButtonManager_SWC_1.h Rte_CDD_SWC_1.h Rte_LedControl_SWC_2.h Rte_Type.h
  group Det_Module
    ./: Det.c Det.h
  group Dio_Module
    ./: Dio.c Dio.h Dio_Cfg.h Dio_LCfg.c Dio_LCfg.h Dio_Regs.h Dio_Types.h
  group Port_Module
    ./: Port.c Port.h Port_Cfg.h Port_LCfg.c Port_LCfg.h Port_Regs.h Port_Types.h
  group Standard_Types
    ./: Common_Macros.h Compiler.h Platform_Types.h Std_Types.h
  group Systick_Module
    ./: Systick.c Systick.h Systick_Regs.h
