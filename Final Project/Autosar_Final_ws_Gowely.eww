<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Autosar_Final_Project_Gowely.ewp</path>
    </project>
    <batchBuild />
</workspace>
